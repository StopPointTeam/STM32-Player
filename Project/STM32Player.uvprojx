# Keil uVision project STM32Player.uvprojx, settings and files
target STM32Player (6160000::V6.16::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32Player +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\User\Main;..\Core;..\Libraries\HAL_Lib\Inc;..\Libraries\FatFs;..\Libraries\FatFs\drivers;..\System\systick;..\System\sys;..\System\spi;..\System\gpio;..\System\tim;..\System\usart;..\System\adc;..\Hardware\led;..\Hardware\key;..\Hardware\lcd;..\Hardware\sdio;..\Hardware\hc25;..\User\GameEngine;..\User\Picture;..\User\SD;..\User\WLAN;..\User\Clock;..\User\APP_Reader;..\User\APP_Video;..\User\APP_Plane;..\User\APP_Weather;..\User\APP_Setting;..\User\FxLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=6314,6329
  group Main
    ../User/Main/: main.c
  group Core
    ../Core/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s stm32h7xx_it.c system_stm32h7xx.c
  group HAL_Lib
    ../Libraries/HAL_Lib/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_lptim.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c
  group System
    ../System/sys/: sys.c
    ../System/spi/: spi.c
    ../System/tim/: tim.c
    ../System/usart/: uart.c
    ../System/systick/: systick.c
    ../System/adc/: adc.c
  group Hardware
    ../Hardware/led/: led.c
    ../Hardware/key/: key.c
    ../Hardware/lcd/: lcd.c
    ../Hardware/sdio/: sdio.c
    ../Hardware/hc25/: hc25.c
  group GameEngine
    ../User/GameEngine/: GameEngine.c GE_Draw.c GE_Font.c GE_GUI.c
  group FatFs
    ../Libraries/FatFs/: diskio.c ff.c ff_gen_drv.c
    ../Libraries/FatFs/option/: syscall.c cc936.c
    ../Libraries/FatFs/drivers/: sd_diskio_dma.c
  group Picture
    ../User/Picture/: Picture.c
  group SD
    ../User/SD/: SD.c
  group WLAN
    ../User/WLAN/: WLAN.c
  group Clock
    ../User/Clock/: Clock.c
  group APP_Reader
    ../User/APP_Reader/: APP_Reader.c
  group APP_Video
    ../User/APP_Video/: APP_Video.c
  group APP_Plane
    ../User/APP_Plane/: APP_Plane.c
  group APP_Weather
    ../User/APP_Weather/: APP_Weather.c
  group APP_Setting
    ../User/APP_Setting/: APP_Setting.c
  group Fxlib
    ../User/FxLib/: fxlib.c
